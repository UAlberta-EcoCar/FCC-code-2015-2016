<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\avr32_drivers_pwm4_example_uc3c_ek.ewp</path>
  </project>
  <batchBuild/>
</workspace>
