# IAR project avr32_drivers_pwm4_example_uc3c_ek.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3C_EK
  ICCAVR32.CCIncludePath2: ..\..\..\..\..\boards\uc3c_ek; ..\..\..; ..\..\..\..\intc; ..\..\..\..\..\boards; ..\..\..\..\..\utils\preprocessor; ..\..\..\..\..\..\common\boards; ..\..\..\..\scif; ..\..\..\..\..\..\common\utils; ..\..\..\..\gpio; ..\..\..\..\pm; ..\..\..\..\flashc; ..\..\..\..\..\utils
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3C_EK
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\..\..\..\..\utils\linker_scripts\at32uc3c\0256c\iar\lnkuc3c0256c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group (top)
    ../../../../pm/: power_clocks_lib.c pm_uc3c.c
    ../../: pwm4_example.c
    ../../../: pwm4.c
    ../../../../intc/: intc.c exception.s82
    ../../../../flashc/: flashc.c
    ../../../../scif/: scif_uc3c.c
    ../../../../gpio/: gpio.c
    ../../../../../utils/startup/: trampoline_uc3.s82
